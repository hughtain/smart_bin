# Keil uVision project BH-F103.uvprojx, settings and files
target xiaoling (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\HCSR;..\..\User\Usart;..\..\User\ultrasound;..\..\User\systick;..\..\User\timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c stm32f10x_usart.c stm32f10x_tim.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/HCSR/: hcsr.c
    ../../User/Usart/: usart.c
    ../../User/systick/: systick.c
    ../../User/ultrasound/: ultrasound.c
    ../../User/timer/: time.c
  group ReadMe
    ../../ReadMe/: readme.txt
